FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://user.cfg \
    file://0001-drm-xlnx-add-fixed-hdmi-output-component.patch \
"
